IMAGE_INSTALL:append = " liblc3 libopus codec packagegroup-core-buildessential" 